# Keil uVision project Farm.uvproj, settings and files
target Farm (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Farm +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\AIR_TEMPERATURE_HUMIDITY;..\HARDWARE\BUZZER;..\HARDWARE\CUSTOM_DEVICES;..\HARDWARE\DIRT_HUMIDITY;..\HARDWARE\DIRT_TEMPERATURE;..\HARDWARE\FAN;..\HARDWARE\FLASH;..\HARDWARE\LED;..\HARDWARE\LIGHT;..\HARDWARE\UART;..\HARDWARE\WATERING;..\HARDWARE\TIM;..\HARDWARE\SPI;..\HARDWARE\AD;..\HARDWARE\DHT11;..\HARDWARE\DS18B20;..\HARDWARE\NETWORK;..\HARDWARE\NETWORK\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../README/: README.txt
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/FAN/: FAN.c
    ../HARDWARE/BUZZER/: BUZZER.c
    ../HARDWARE/UART/: UART.c
    ../HARDWARE/FLASH/: FLASH.c
    ../HARDWARE/TIM/: TIM.c
    ../HARDWARE/AD/: AD.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/DS18B20/: DS18B20.c
    ../HARDWARE/NETWORK/: NETWORK.c
